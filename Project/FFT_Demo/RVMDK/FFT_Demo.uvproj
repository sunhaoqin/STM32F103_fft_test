# Keil uVision project FFT_Demo.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\inc;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F10x_DSP_Lib\inc;..\..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: main.c stm32f10x_it.c stm3210b_lcd.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_spi.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c
  group RVMDK
    ../../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group DSP_Lib
    ../../../Libraries/STM32F10x_DSP_Lib/src/: PID_C_stm32.c iir_stm32.c
    ../../../Libraries/STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s fir_stm32.s iirarma_stm32.s PID_stm32.s
  group DOC
    ../: readme.txt
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group HARDWARE
    ../../HARDWARE/ADC/: adc.c
